<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Logo_Back_Light_Control.ewp</path>
  </project>
  <batchBuild/>
</workspace>


