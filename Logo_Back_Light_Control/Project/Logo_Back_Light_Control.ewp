# IAR project Logo_Back_Light_Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\Drivers; ..\STM32F0xx_StdPeriph_Driver; ..\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Logo_Back_Light_Control.srec
  ILINK.IlinkOutputFile: Logo_Back_Light_Control.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/: main.c
  group Drivers
    ../Drivers/: adc.c flash.c gpio.c hal.c stm32f0xx_it.c timer.c
  group StartUp
    ../STM32F0xx_StdPeriph_Driver/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
    ../STM32F0xx_StdPeriph_Driver/: system_stm32f0xx.c
