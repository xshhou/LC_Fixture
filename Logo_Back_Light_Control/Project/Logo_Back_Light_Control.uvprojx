# Keil uVision project Logo_Back_Light_Control.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Logo_Back_Light_Control +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER
  c include: ..\Drivers;..\STM32F0xx_StdPeriph_Driver;..\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ../APP/: main.c
  group Drivers
    ../Drivers/: adc.c flash.c gpio.c hal.c stm32f0xx_it.c timer.c
  group StartUp
    ./: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c
    ../STM32F0xx_StdPeriph_Driver/: system_stm32f0xx.c
